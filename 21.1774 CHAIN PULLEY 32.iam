# Autodesk Inventor assembly: 21.1774 CHAIN PULLEY 32
## iProperties
Created: 2007-05
Part Number: 21.1774 CHAIN PULLEY 32
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
